# Keil uVision project mqtt-relay.uvprojx, settings and files
target sim800c-mqtt (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sim800c-mqtt +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\sys;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\STMFLASH;..\HARDWARE\sim900a;..\HARDWARE\usart;..\HARDWARE\md5;..\HARDWARE\mqtt;..\HARDWARE\parameter;..\HARDWARE\timer;..\HARDWARE\timer_task;..\HARDWARE\json;..\HARDWARE\system;..\UTILS\MQTTPacket;..\UTILS\aliyun;..\UTILS;..\UTILS\digest;..\HARDWARE\relay
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/sim900a/: sim900a.c
    ../HARDWARE/usart/: usart.c
    ../HARDWARE/parameter/: parameter.c
    ../HARDWARE/mqtt/: mqtt-user.c
    ../HARDWARE/timer/: timer.c
    ../HARDWARE/timer_task/: timer_task.c
    ../HARDWARE/json/: frozen.c
    ../HARDWARE/system/: system.c
    ../HARDWARE/relay/: relay.c
  group UTILS
    ../UTILS/MQTTPacket/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c md5.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_tim.c
  group README
    ../: README.TXT
